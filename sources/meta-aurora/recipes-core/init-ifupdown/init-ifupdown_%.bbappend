FILESEXTRAPATHS_prepend := "${THISDIR}/files:" 
SRC_URI_raspberrypi4 += "file://0001-Set-static-ip-on-wired-connection.patch"
