FILESEXTRAPATHS_prepend := "${THISDIR}/files:" 
COMPATIBLE_MACHINE = "raspberrypi4"
SRC_URI += "file://0001-Set-static-ip-on-wired-connection.patch"
